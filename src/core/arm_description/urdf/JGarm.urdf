Commit message: 重实现IK逆解及轨迹规划

File: src/core/arm_description/urdf/JGarm.urdf (robot description, URDF)
Before this commit: robot JGarm, 7 links, 6 joints
Joints:
- joint joint_5: limit lower=-1.967 upper=1.937 effort=6 velocity=20 -> lower=-0.70 upper=0.75 effort=6 velocity=20
